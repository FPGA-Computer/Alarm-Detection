# Keil uVision project Alarm.uvprojx, settings and files
target Alarm (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Alarm
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Src
    ./: startup_stm32f030.s adc.c main.c rcc.c gpio.h hardware.h hardware.c fifo.c font 5x8.c Nokia5110.c audio.c intfft.c intfft.h
